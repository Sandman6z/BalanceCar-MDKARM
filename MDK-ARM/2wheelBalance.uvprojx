# Keil uVision project 2wheelBalance.uvprojx, settings and files
target 2 wheel Balance (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2wheelBalance +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CMSIS;..\FWlib\inc;..\User;..\User\inc;..\User\OLED;..\User\HC05;..\User\motor;..\User\MPU6050;..\User\ultrasonic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group BSP
    ../User/src/: bsp.c ADC.c usart.c I2C.c infrare.c
    ../User/MPU6050/: MPU6050.c
    ../User/ultrasonic/: ultrasonic.c
    ../User/motor/: motor.c
    ../User/HC05/: hc05.c
    ../User/OLED/: I2C2.c oled-iic.c
  group SYS
    ../User/src/: debug.c systick.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/src/: common.c communicate.c control.c dataflash.c display.c manage.c
software components: CMSIS:CORE 4.3.0
